## Kconfig
```kconfig
config JALDI
	tristate "Atheros 802.11n wireless cards support"
	---help---
	  This is the Jaldi module.
```
